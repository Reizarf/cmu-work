//  edited by Peyton Grattino on 10/3/20.
//  Copyright © 2020 Peyton Grattino. All rights reserved.
//  declare that all material in this assessment task is my work except where there is clear acknowledge-mentorreferencetotheworkofothers. I further declare that I have complied and agreed to the CMU Academic Integrity Policy at the University website. http://www.coloradomesa.edu/student-services/documents
// I worked very closely with Sebastian Medina, Lauren Lewis, and the tutors. Any similarities in my code would be due to inspiration and colaboration on this assignment.
//  Author’s Name: Peyton Grattino  UID(700#): 700492650 Date: 10/3/20
#include <iostream>
#include <cstdlib>
#include "subs.cpp"
#include "subs.h"
using namespace std;

int main(void)
{
    int i, cardNo, deck[52], hand1[5], hand2[5], change[5], v1, v2, winner, randNum = rand(), numOfCards, card2Remove;
	unsigned int seed;
    char ch, cardName[20], handtype1[20], handtype2[20], yesNo, yesNo2;
	
/*
	PRELIMINARY CODE
*/
/*
	cout << "Steps 1-4:\nEnter a card number: ";
	cin >> cardNo;
	
     while (GetCardName(cardNo,cardName))
	{
		cout << "Card Number " << cardNo << " is the " << cardName
			<< ".\nEnter a card number: ";
		cin >> cardNo;
	}
 */
	cout << "Enter a random seed: ";
    cin >> seed;


/*
	Start of program proper
*/
	srand(seed);
    ShuffleDeck(deck);
    DealPokerHands(deck,hand1,hand2);
    v1 = HandValue(hand1, handtype1);
    v2 = HandValue(hand2, handtype2);
    //This is allowing player 1 to take there turn to exchange cards
    cout << "Player one:" << endl;
    char temp[20];
    for (int i = 0; i < 5; i++){
        GetCardName(hand1[i],temp);
        cout << i+1 << ") " << temp << endl;
    }
    cout << "Would you like to replace any cards? (y/n)" << endl;
    cin >> yesNo;
    if (yesNo == 'y' || yesNo == 'Y'){
        cout << "How many cards would you like to replace? ";
        cin >> numOfCards;
        cout << "Please enter the number of the cards separated with a space:" << endl;
        for (int i = 0; i < (numOfCards); i++){
            cin >> card2Remove;
            swap (hand1[card2Remove], deck[rand() % 52+11]);
        }
        cout << "Here are your new cards:" << endl;
        for (int i = 1; i < 6; i++){
            //cout << hand1[i] << endl;
            GetCardName(hand1[i - 1],temp);
            cout << i << ") " << temp << endl;
        }
    }
    
    //this will make 24 blank lines
    for(int i = 0; i < 25; i++)
        cout << endl;
    
    //player2
    cout << "Player Two:" << endl;
    card2Remove = 0; //This is to make sure that player1 inputs are still not used.
    numOfCards = 0;
    for (int i = 1; i < 6; i++){
        GetCardName(hand2[i],temp);
        cout << i << ") " << temp << endl;
    }
    cout << "Would you like to replace any cards? (y/n)" << endl;
    cin >> yesNo2;
    if (yesNo2 == 'y' || yesNo2 == 'Y'){
        cout << "How many cards would you like to replace? ";
        cin >> numOfCards;
        cout << "Please enter the number of the cards separated by pressing enter:" << endl;
        for (int i = 0; i <= (numOfCards); i++){
            cin >> card2Remove;
            swap(hand2[card2Remove], deck[rand() % 52+11]);
        }
        cout << "Here are your new cards:" << endl;
        for (int i = 1; i < 6; i++){
            //cout << hand1[i] << endl;
            GetCardName(hand2[i - 1],temp);
            cout << i << ") " << temp << endl;
        }
    }
    //this will make 24 blank lines
    for(int i = 0; i < 25; i++)
        cout << endl;
    
    cout << "The winner is: ";
    winner = WhoWins(hand1, v1, hand2, v2);
    if (winner == 1)
        cout << "Player 1" << endl;
    if (winner == 2)
        cout << "Player 2" << endl;
    return 0;
}
